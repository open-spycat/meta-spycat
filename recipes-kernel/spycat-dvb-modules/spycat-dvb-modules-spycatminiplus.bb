KV = "4.10.0"
SRCDATE = "20170515"
MODNAMES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x"

require spycat-dvb-modules.inc

COMPATIBLE_MACHINE = "spycatminiplus"

SRC_URI[md5sum] = "b2d4d3d4915856725d5fb5b21945296b"
SRC_URI[sha256sum] = "930ebdb3a9168baba020db91bb65fac75bffa05a272815602e3363b79ca0c305"
